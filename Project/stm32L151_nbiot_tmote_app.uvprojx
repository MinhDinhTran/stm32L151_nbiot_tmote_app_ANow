# Keil uVision project stm32L151_nbiot_tmote_app.uvprojx, settings and files
target stm32L151_nbiot_tmote_app (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32L151_nbiot_tmote_app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c include: ..\Core;..\HALLibraries\Inc;..\User;..\System\Delay;..\System\Sys;..\System\Usart;..\Libraries\Radar;..\Libraries\Inspect;..\Libraries\NBIot;..\Libraries\MQTTSNPacket\src;..\Libraries\MQTTSNPacket\mqttsn;..\Libraries\Radio;..\Libraries\Radio\radio_inc;..\Libraries\Radio\radio_src;..\Libraries\Xtea;..\Hardware\RTC;..\Hardware\EEPROM;..\Hardware\IWDG;..\Hardware\IIC;..\Hardware\QMC5883L;..\Hardware\SWITCH;..\Hardware\VBAT;..\Hardware\BEEP;..\Hardware\RADAR;..\Hardware\NET;..\Hardware\TEMPERATURE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Core
    ../Core/: startup_stm32l151xb.s cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group HALLibraries
    ../HALLibraries/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group Hardware
    ../Hardware/RTC/: hal_rtc.c
    ../Hardware/EEPROM/: hal_eeprom.c
    ../Hardware/IWDG/: hal_iwdg.c
    ../Hardware/BEEP/: hal_beep.c
    ../Hardware/SWITCH/: hal_switch.c
    ../Hardware/VBAT/: hal_vbat.c
    ../Hardware/TEMPERATURE/: hal_temperature.c
    ../Hardware/IIC/: hal_iic.c
    ../Hardware/QMC5883L/: hal_qmc5883l.c
    ../Hardware/RADAR/: hal_radar.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Usart/: usart.c
  group User
    ../User/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c stm32l1xx_config.c system_stm32l1xx.c platform_map.c platform_map.h platform_config.c platform_config.h
  group Radar
    ../Libraries/Radar/: radar_api.c radar_adc.c radar_dac.c radar_dma.c radar_timer.c stm32_dsp.h tmesh_radar_algorithm.h tmesh_radar_algorithm.lib
  group NBIot
    ../Libraries/NBIot/: nbiotconfig.c nbiotfunc.c nbiottransport.c
  group MqttSNLib
    ../Libraries/MQTTSNPacket/src/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
  group MqttSN
    ../Libraries/MQTTSNPacket/mqttsn/: mqttsnconfig.c mqttsnfunc.c mqttsntransport.c
  group Net
    ../Hardware/NET/: net_coap_message_operate.c net_coap_app.c net_mqttsn_message_operate.c net_mqttsn_app.c
  group Radio
    ../Libraries/Radio/: hal_rf.c
  group Xtea
    ../Libraries/Xtea/: tmesh_xtea.h tmesh_xtea.lib
  group Readme
    ../Doc/: Readme.txt
